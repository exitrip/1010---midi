# Keil uVision project Blinky.uvproj, settings and files
target Simulator (MCS-51)
  device: P89LPC936 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: Blinky +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: Blinky.c uart.c LUTFreq.c riff.c song.c LUTsin.c
  group Startup Code
    ./: START900.A51
  group Documentation
    ./: ABSTRACT.TXT
  group ISP
    ./: LPC_ISP_16K_V04.a51 no_touch.a51
target MCB900 - Run (MCS-51)
  device: P89LPC932 Philips
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x1FF) CLOCK(12000000) MODP2
  output: Blinky +hex
  c flags: Optimize=8 SizeSpeed=1
target EPM900 - Emulator (MCS-51)
  device: P89LPC936 NXP (founded by Philips)
  cpu: as above
  output: Blinky +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC\Philips
